options:
  parameters:
    generate_options: qt_gui
    id: gpio_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: robotics_gpi_0
  id: robotics_gpi
  parameters:
    gpio_pin: '13'
    platform: pi3
  states: {}
- name: robotics_gpo_0
  id: robotics_gpo
  parameters:
    gpio_pin: '11'
    platform: pi3
  states: {}

connections:
- [robotics_gpi_0, '0', robotics_gpo_0, '0']

metadata:
  file_format: 1
